# Keil uVision project StepperMotor_Control.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: StepperMotor_Control +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c StepperMotor.c delay.c
  group Include Group
    ./: delay.h StepperMotor.h
