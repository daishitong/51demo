# Keil uVision project Lcd1602.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Lcd1602 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 delay.c Lcd1602.c main.c README.md
  group Include Group
    ./: delay.h Lcd1602.h
