# Keil uVision project Servo_Control.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Servo_Control +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c delay.c README.md Timer2.c Timer2_PWM.c Interrupt.c
  group Include Group
    ./: delay.h Timer.h Timer2.h Timer2_PWM.h pointer.h type.h boolean.h Interrupt.h
