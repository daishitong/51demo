# Keil uVision project Serial_Led.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Serial_Led +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Led.c SerialBase.c Serial.c Interrupt.c README.md
  group Include Group
    ./: Led.h SerialBase.h Serial.h Interrupt.h
