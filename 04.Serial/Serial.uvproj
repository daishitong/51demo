# Keil uVision project Serial.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Serial +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Serial.c delay.c
  group Include Group
    ./: Serial.h delay.h
