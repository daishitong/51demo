# Keil uVision project Passive_Buzzer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Passive_Buzzer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c T2_Delay.c MidiBuzzer.c
  group Include Group
    ./: MidiBuzzer.h T2_delay.h boolean.h
