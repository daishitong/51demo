# Keil uVision project Ultrasound_Serial.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Ultrasound_Serial +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c HC_SR04.c delay.c SerialBase.c README.md TimeCounter2.c
  group Include Group
    ./: delay.h HC_SR04.h SerialBase.h TimeCounter2.h
