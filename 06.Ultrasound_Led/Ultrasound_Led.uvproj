# Keil uVision project Ultrasound_Led.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Ultrasound_Led +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c HC_SR04.c Timer0.c delay.c Led.c ExternalInterrupt0.c Interrupt.c
  group Include Group
    ./: delay.h HC_SR04.h Led.h Timer0.h ExternalInterrupt0.h Interrupt.h boolean.h
